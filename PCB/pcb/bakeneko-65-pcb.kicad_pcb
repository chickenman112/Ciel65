# Repository chickenman112/Ciel65

## KiCad design PCB/pcb/bakeneko-65-pcb.kicad_pcb

Board: 2 copper layers, 303.8 x 94.2 mm, 161 parts (161 on the bottom side), 104 nets.

Parts:
C1, C2, C3: 0.1u; C_0805_2012Metric
C4: 10u; C_0805_2012Metric
C5, C6: 22p; C_0805_2012Metric
C7: 1u; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68: 1N4148; D_SOD-123
F1: 500mA; Fuse_1206_3216Metric
J1: JST SH 4-pin; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J2: AVR-ISP-6; ISP
MX1, MX2, MX3, MX4, MX5, MX6, MX7, MX8, MX9, MX10, MX11, MX12, MX13, MX14, MX15, MX16, MX19, MX20, MX21, MX22, MX23, MX24, MX25, MX26, MX27, MX28, MX29, MX30, MX32, MX35, MX36, MX37, MX38, MX39, MX40, MX41, MX42, MX43, MX44, MX45, MX47, MX49, MX50, MX51, MX52, MX53, MX54, MX55, MX56, MX57, MX58, MX60, MX61, MX63, MX68, MX69, MX70: 1u; MXOnly-1U-Hotswap-NoLED
MX17: 2u; MXOnly-2U-Hotswap-NoLED
MX18, MX31, MX62, MX64, MX67: 1.5u; MXOnly-1.5U-Hotswap-NoLED
MX33, MX66, MX71, MX72, MX73, MX75: 1.25u; MXOnly-1.25U-Hotswap-NoLED
MX34, MX59: 1.75u; MXOnly-1.75U-Hotswap-NoLED
MX46, MX48: 2.25u; MXOnly-2.25U-Hotswap-NoLED
MX65: 7u; MXOnly-7U-Hotswap-NoLED
MX74: 6.25u; MXOnly-6.25U-Hotswap-NoLED
R1, R4: 10k; R_0805_2012Metric
R2, R3: 22; R_0805_2012Metric
SW1: Reset; SW_SPST_TL3342
U1: SRV05-4; SOT-23-6
U2: ATmega32U4-AU; QFN-44-1EP_7x7mm_P0.5mm_EP5.2x5.2mm
Y1: 16MHz; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, F1.1, J2.2 (VCC), R1.2, U2.2 (UVCC), U2.7 (VBUS), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC)
/MCU_D+: R2.1, U2.4 (D+)
/MCU_D-: R3.1, U2.3 (D-)
COL0: MX1.2 (B), MX18.2 (B), MX33.2 (B), MX34.2 (B), MX48.2 (B), MX62.2 (B), MX71.2 (B), U2.37 (PF6)
COL1: MX2.2 (B), MX19.2 (B), MX35.2 (B), MX63.2 (B), MX72.2 (B), U2.8 (PB0)
COL2: MX3.2 (B), MX20.2 (B), MX36.2 (B), MX49.2 (B), MX64.2 (B), MX73.2 (B), U2.40 (PF1)
COL3: MX4.2 (B), MX21.2 (B), MX37.2 (B), MX50.2 (B), U2.32 (PC7)
COL4: MX5.2 (B), MX22.2 (B), MX38.2 (B), MX51.2 (B), U2.31 (PC6)
COL5: MX6.2 (B), MX23.2 (B), MX39.2 (B), MX52.2 (B), U2.30 (PB6)
COL6: MX7.2 (B), MX24.2 (B), MX40.2 (B), MX53.2 (B), MX65.2 (B), MX74.2 (B), U2.29 (PB5)
COL7: MX8.2 (B), MX25.2 (B), MX41.2 (B), MX54.2 (B), U2.28 (PB4)
COL8: MX9.2 (B), MX26.2 (B), MX42.2 (B), MX55.2 (B), U2.27 (PD7)
COL9: MX10.2 (B), MX27.2 (B), MX43.2 (B), MX56.2 (B), MX66.2 (B), U2.26 (PD6)
COL10: MX11.2 (B), MX28.2 (B), MX44.2 (B), MX57.2 (B), U2.25 (PD4)
COL11: MX12.2 (B), MX29.2 (B), MX45.2 (B), MX58.2 (B), MX67.2 (B), MX75.2 (B), U2.22 (PD5)
COL12: MX13.2 (B), MX30.2 (B), MX59.2 (B), MX68.2 (B), U2.21 (PD3)
COL13: MX14.2 (B), MX31.2 (B), MX46.2 (B), MX60.2 (B), MX69.2 (B), U2.20 (PD2)
COL14: MX15.2 (B), MX17.2 (B), U2.19 (PD1)
COL15: MX16.2 (B), MX32.2 (B), MX47.2 (B), MX61.2 (B), MX70.2 (B), U2.18 (PD0)
D+: J1.3, R2.2, U1.1 (IO1)
D-: J1.2, R3.2, U1.6 (IO4)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, J1.4, J2.6 (GND), R4.1, SW1.1, U1.2 (VN), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), Y1.2, Y1.4
MISO: J2.1 (MISO), U2.11 (PB3)
MOSI: J2.4 (MOSI), U2.10 (PB2)
unnamed: C7.1, U2.6 (UCAP)
unnamed: D1.2 (A), MX1.1 (A)
unnamed: D2.2 (A), MX2.1 (A)
unnamed: D3.2 (A), MX3.1 (A)
unnamed: D4.2 (A), MX4.1 (A)
unnamed: D5.2 (A), MX5.1 (A)
unnamed: D6.2 (A), MX6.1 (A)
unnamed: D7.2 (A), MX7.1 (A)
unnamed: D8.2 (A), MX8.1 (A)
unnamed: D9.2 (A), MX9.1 (A)
unnamed: D10.2 (A), MX10.1 (A)
unnamed: D11.2 (A), MX11.1 (A)
unnamed: D12.2 (A), MX12.1 (A)
unnamed: D13.2 (A), MX13.1 (A)
unnamed: D14.2 (A), MX14.1 (A)
unnamed: D15.2 (A), MX15.1 (A), MX17.1 (A)
unnamed: D16.2 (A), MX16.1 (A)
unnamed: D17.2 (A), MX18.1 (A)
unnamed: D18.2 (A), MX19.1 (A)
unnamed: D19.2 (A), MX20.1 (A)
unnamed: D20.2 (A), MX21.1 (A)
unnamed: D21.2 (A), MX22.1 (A)
unnamed: D22.2 (A), MX23.1 (A)
unnamed: D23.2 (A), MX24.1 (A)
unnamed: D24.2 (A), MX25.1 (A)
unnamed: D25.2 (A), MX26.1 (A)
unnamed: D26.2 (A), MX27.1 (A)
unnamed: D27.2 (A), MX28.1 (A)
unnamed: D28.2 (A), MX29.1 (A)
unnamed: D29.2 (A), MX30.1 (A)
unnamed: D30.2 (A), MX31.1 (A)
unnamed: D31.2 (A), MX32.1 (A)
unnamed: D32.2 (A), MX33.1 (A), MX34.1 (A)
unnamed: D33.2 (A), MX35.1 (A)
unnamed: D34.2 (A), MX36.1 (A)
unnamed: D35.2 (A), MX37.1 (A)
unnamed: D36.2 (A), MX38.1 (A)
unnamed: D37.2 (A), MX39.1 (A)
unnamed: D38.2 (A), MX40.1 (A)
unnamed: D39.2 (A), MX41.1 (A)
unnamed: D40.2 (A), MX42.1 (A)
unnamed: D41.2 (A), MX43.1 (A)
unnamed: D42.2 (A), MX44.1 (A)
unnamed: D43.2 (A), MX45.1 (A)
unnamed: D44.2 (A), MX46.1 (A)
unnamed: D45.2 (A), MX47.1 (A)
unnamed: D46.2 (A), MX48.1 (A)
unnamed: D47.2 (A), MX49.1 (A)
unnamed: D48.2 (A), MX50.1 (A)
unnamed: D49.2 (A), MX51.1 (A)
unnamed: D50.2 (A), MX52.1 (A)
unnamed: D51.2 (A), MX53.1 (A)
unnamed: D52.2 (A), MX54.1 (A)
unnamed: D53.2 (A), MX55.1 (A)
unnamed: D54.2 (A), MX56.1 (A)
unnamed: D55.2 (A), MX57.1 (A)
unnamed: D56.2 (A), MX58.1 (A)
unnamed: D57.2 (A), MX59.1 (A)
unnamed: D58.2 (A), MX60.1 (A)
unnamed: D59.2 (A), MX61.1 (A)
unnamed: D60.2 (A), MX62.1 (A), MX71.1 (A)
unnamed: D61.2 (A), MX63.1 (A), MX72.1 (A)
unnamed: D62.2 (A), MX64.1 (A), MX73.1 (A)
unnamed: D63.2 (A), MX65.1 (A), MX74.1 (A)
unnamed: D64.2 (A), MX66.1 (A)
unnamed: D65.2 (A), MX67.1 (A), MX75.1 (A)
unnamed: D66.2 (A), MX68.1 (A)
unnamed: D67.2 (A), MX69.1 (A)
unnamed: D68.2 (A), MX70.1 (A)
unnamed: R4.2, U2.33 (~HWB~/PE2)
RESET: J2.5 (~RST), R1.1, SW1.2, U2.13 (~RESET)
ROW0: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), U2.1 (PE6)
ROW1: D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), U2.12 (PB7)
ROW2: D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), D43.1 (K), D44.1 (K), D45.1 (K), U2.36 (PF7)
ROW3: D46.1 (K), D47.1 (K), D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), D56.1 (K), D57.1 (K), D58.1 (K), D59.1 (K), U2.39 (PF4)
ROW4: D60.1 (K), D61.1 (K), D62.1 (K), D63.1 (K), D64.1 (K), D65.1 (K), D66.1 (K), D67.1 (K), D68.1 (K), U2.38 (PF5)
SCK: J2.3 (SCK), U2.9 (PB1)
VBUS: F1.2, J1.1, U1.5 (VP)
XTAL1: C6.2, U2.17 (XTAL1), Y1.1
XTAL2: C5.2, U2.16 (XTAL2), Y1.3

## Commit log

2023-01-31 Undo
